# Keil uVision project Sample.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D17 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x2FF) CLOCK(25000000)
  output: Sample +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source;.\Source\Driver\Include;.\Source\Driver\Source;.\Source\Middleware\Include;.\Source\Middleware\Source
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: MAIN.c
    ./Source/Driver/Source/: MG82F6D17_COMMON_DRV.c MG82F6D17_IAP_DRV.c MG82F6D17_INTERRUPT.c MG82F6D17_WIZARD.c
